# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_ARMCM3_LM; PACK_STRUCT_END=; ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: pa082, pe513, pe167, pe550, pe144, pe191, pe177, pa039, pa050
  ICCARM.CCIncludePath2: ; ..\Common\ethernet; ..\..\..\..\; ..\Common\drivers\LuminaryMicro; ..\common\include; ..\..\source\include; webserver; ..\Common\ethernet\uIP\uip-1.0\uip; C:\StellarisWare\boards\ek-lm3s8962\; C:\StellarisWare\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3Sxxxx.icf
  ILINK.IlinkAdditionalLibs: ..\Common\drivers\LuminaryMicro\IAR\driverlib.a; ..\Common\drivers\LuminaryMicro\IAR\grlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: constantDefs.h currentTrain.c header.h randomInteger.c SerialCom.c switchControl.c trainCom.c
  group Demo files
    ../Common/Minimal/: IntQueue.c
    ./: IntQueueTimer.c main.c timertest.c
    ParTest/: ParTest.c
  group Library files
    ../Common/drivers/LuminaryMicro/IAR/: driverlib.a grlib.a
    ./: formike128x128x16.c osram128x64x4.c rit128x96x4.c
  group Scheduler files
    ../../Source/portable/MemMang/: heap_2.c
    ../../Source/: list.c queue.c tasks.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System files
    ./: startup_ewarm.c
  group uIP files
    webserver/: emac.c http-strings.c httpd-cgi.c httpd-fs.c httpd.c uIP_Task.c
    ../Common/ethernet/uIP/uip-1.0/uip/: psock.c timer.c uip.c uip_arp.c
